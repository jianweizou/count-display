# Keil uVision project SNC7312.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SNC7312
  AfterMake: fromelf --bin ".\obj\SNC7312.axf" --output ".\obj\SNC7312.bin"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --locale=english
  c include: H;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --no_remove
  group Startup
    Startup/: LoadTable.s startup_SNC7312.s
  group Sym
    ./Sym/: SNC7312_ROM_201511271015.sym
    ./Lib/: SNC7312_Timer_V1.001.lib
  group User
    ./src/: main.c i2c.c OLED.c count.c fontdata.c
software components: CMSIS:CORE 4.3.0
