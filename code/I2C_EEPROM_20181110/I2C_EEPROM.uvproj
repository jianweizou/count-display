# Keil uVision project I2C_EEPROM.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_EEPROM +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: ..\..\Include;..\Include
  group Source
    ./Code/: I2C_EEPROM.c main.c FontData.c OLED.c count.c dataflash.c i2c.c ds1302.c
  group Common
    ./Code/: Delay.c
  group Startup
    ../Startup/: STARTUP.A51
